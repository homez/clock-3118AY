# Keil uVision project clock-3118AY.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: clock-3118AY +hex
  c flags: Optimize=8 SizeSpeed=1
  group clock-3118AY
    ./: STARTUP.A51 main.c delay.c display.c timer.c adc.c ds1302.c key.c alarm.c fonts.c eeprom.c settings.c holidays.c
